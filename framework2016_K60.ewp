# IAR project framework2016_K60.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DX256xxx10 Freescale MK60DX256xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: LPLD_K60
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: framework2016_K60.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\128KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  ICCARM.CCIncludePath2: source; common; LPLD; LPLD\HW; LPLD\DEV; USB\class; USB\common; USB\descriptor; USB\driver
  ILINK.IlinkIcfFile: E:\freescale_racing\SmartCar_K60_TeamBLANK\iar_config_files\LPLD_K60DN512_FLASH.icf
configuration BOOT (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  OBJCOPY.OOCOutputFile: framework2016_K60.bin
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_BOOT_K60DN512.icf
  group app
    source/: Bluetooth.c Bluetooth.h Cam.c Cam.h CCD.c CCD.h Flash.c Flash.h framework2016.c HMI.c HMI.h IMU.c IMU.h includes.h Mag.c Mag.h Motor.c Motor.h OLED.c OLED.h OLED_UI.c OLED_UI.h PIT.c PIT.h typedef.h UART.c UART.h UI_Operation.c UI_Operation.h USB_callback.c USB_callback.h
    LPLD/DEV/: Setting.h
  group lib/common
    common/: common.h MK60DZ10.h relocate.c relocate.h startup_K60.s system_MK60DZ10.c system_MK60DZ10.h
    source/: k60_card.h
  group lib/LPLD
    LPLD/DEV/: DEV_MMA8451.c DEV_MMA8451.h
    LPLD/HW/: HW_I2C.c HW_I2C.h HW_MCG.c HW_MCG.h HW_USB.c HW_USB.h
    LPLD/: LPLD_Drivers.h
  group USB
    USB/common/: derivative.h types.h usb_class.c usb_class.h USB_Config.h usb_framework.c usb_framework.h user_config.h
    USB/driver/: mouse_button.c mouse_button.h usb_bdt_kinetis.h usb_dci_kinetis.c usb_dci_kinetis.h usb_dciapi.h usb_devapi.h usb_driver.c usb_driver.h usbevent.c usbevent.h virtual_com.c virtual_com.h
    USB/class/: usb_cdc.c usb_cdc.h usb_cdc_pstn.c usb_cdc_pstn.h usb_hid.c usb_hid.h
    USB/descriptor/: usb_descriptor_cdc.c usb_descriptor_cdc.h
